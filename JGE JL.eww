<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\Users\minhv\OneDrive - CCSU\Desktop\pro.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Users\minhv\OneDrive - CCSU\Desktop\tap.ewp</path>
    </project>
    <batchBuild />
</workspace>
